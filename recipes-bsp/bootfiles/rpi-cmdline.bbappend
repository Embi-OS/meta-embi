CMDLINE += "${APPEND}"
