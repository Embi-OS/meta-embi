############################################################################
##
## This file is part of the meta-embi layer.
##
############################################################################
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

