############################################################################
##
## This file is part of the meta-embi layer.
##
############################################################################

DESCRIPTION = "SDK toolchain for the Embi OS image"

TOOLCHAIN_TARGET_TASK += " \
    packagegroup-rpi \
    packagegroup-embi \
"
