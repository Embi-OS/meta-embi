############################################################################
##
## This file is part of the meta-embi layer.
##
############################################################################

DEFAULT_TIMEZONE="Europe/Zurich"
